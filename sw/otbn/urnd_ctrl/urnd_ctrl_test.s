/* Copyright lowRISC contributors (OpenTitan project). */
/* Licensed under the Apache License, Version 2.0, see LICENSE for details. */
/* SPDX-License-Identifier: Apache-2.0 */

/*
 * Test of the OTBN URND control interface.
 *
 * It crashes if something went wrong.
 */

.section .text.start

  bn.xor w31, w31, w31

  addi x10, x0, 0x1             /* STOP */
  addi x11, x0, 0x2             /* START */
  addi x12, x0, 0x4             /* RESTORE */

  /* Check if URND_CTRL_ENABLED is set. */
  csrrs x5, URND_STATUS, x0
  andi  x6, x5, 0x1
  bne   x6, x0, _stop
  unimp

  /* Check if stop works. Stop PRNG, read status and check state. */
_stop:
  csrrs x0, URND_CTRL, x10 /* STOP */
  /* Stop bit must be set. */
  csrrs x5, URND_STATUS, x0
  andi  x6, x5, 0x2
  bne   x6, x0, _stop_keeps_state
  unimp

_stop_keeps_state:
  /* Two reads while stopped must give the same state. */
  bn.wsrr w1, URND_STATE
  bn.wsrr w2, URND_STATE
  bn.xor  w3, w1, w2
  /* Check that the zero flag is set. */
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _restart_and_stop
  unimp

_restart_and_stop:
  /* Save the state and restart. */
  bn.wsrr w10, URND_STATE
  csrrs x0, URND_CTRL, x11 /* START */
  /* Read three URND words. */
  bn.wsrr w20, URND
  bn.wsrr w21, URND
  bn.wsrr w22, URND

  /* Stop it and restore the state. Check that restore bit is set. */
  csrrs x0, URND_CTRL, x10 /* STOP */
  csrrs x0, URND_CTRL, x12 /* RESTORE */
  csrrs x5, URND_STATUS, x0
  andi  x6, x5, 0x4
  bne   x6, x0, _restore
  unimp

_restore:
  loopi 6, 2
    bn.wsrw URND_STATE, w10
    bn.rshi w10, w31, w10 >> 32
  /* Start it again and check that we read the same URND. */
  csrrs x0, URND_CTRL, x11 /* START */
  bn.wsrr w10, URND
  bn.wsrr w11, URND
  bn.wsrr w12, URND

  /* Compare the values. Unrolled for explicit traces. */
  bn.xor w3, w20, w10
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _check_2nd_urnd
  unimp
_check_2nd_urnd:
  bn.xor w3, w21, w11
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _check_3rd_urnd
  unimp
_check_3rd_urnd:
  bn.xor w3, w22, w12
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _used_while_stopped
  unimp

  /* Check the used while stopped flag behaviour. */
_used_while_stopped:
  /* Stop it and then read URND. This should set the USED_WHILE_STOPPED bit.
   * Reading immediately after the stop command tests that the logic correctly handles the
   * early advance signal an instruction generates (generated by the predecoder).
   */
  csrrs x0, URND_CTRL, x10 /* STOP */
  bn.wsrr w10, URND
  csrrs x5, URND_STATUS, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _clear_used_while_stopped
  unimp

_clear_used_while_stopped:
  /* Clear the USED_WHILE_STOPPED bit by restarting and stopping again. */
  csrrs x0, URND_CTRL, x11 /* START */
  nop
  nop
  csrrs x0, URND_CTRL, x10 /* STOP */
  csrrs x5, URND_STATUS, x0
  andi  x6, x5, 0x8
  beq   x6, x0, _immediate_stop_start
  unimp

_immediate_stop_start:
  /* Assume the PRNG is running. Then stop it and immediately start it again. This should delay the
   * stream by 1 state.
   *
   * We test this by first sampling the URND stream. Then we restore it and do the stop/start.
   * Finally we can compare the URND value after the start with the expected value after this many
   * cycles.
   */
  /* Save the state and sample the URND stream. */
  bn.wsrr w10, URND_STATE
  csrrs x0, URND_CTRL, x11 /* START */
  bn.wsrr w20, URND        /* Cycle 0 - State 0 */
  bn.wsrr w21, URND        /* Cycle 1 - State 1 */
  bn.wsrr w22, URND        /* Cycle 2 - State 2 */
  bn.wsrr w23, URND        /* Cycle 3 - State 3 */

  /* Stop it and restore the state. */
  csrrs x0, URND_CTRL, x10 /* STOP */
  csrrs x0, URND_CTRL, x12 /* RESTORE */
  loopi 6, 2
  bn.wsrw URND_STATE, w10
  bn.rshi w10, w31, w10 >> 32

  /* Read the URND stream again. */
  csrrs x0, URND_CTRL, x11 /* START */
  csrrs x0, URND_CTRL, x10 /* STOP  - Cycle 0 - State 0 */
  csrrs x0, URND_CTRL, x11 /* START - Cycle 1 - State 0 */
  bn.wsrr w11, URND        /*       - Cycle 2 - State 1 */
  bn.wsrr w12, URND        /*       - Cycle 3 - State 2 */

  /* Compare the values. Unrolled for explicit traces. */
  bn.xor w3, w21, w11
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _check_stop_start_2nd_urnd
  unimp
_check_stop_start_2nd_urnd:
  bn.xor w3, w22, w12
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _mulvm_advance
  unimp

  /* Check that instructions using URND indirectly also force a PRNG advance. */
_mulvm_advance:
  /* Stop the PRNG and save the state. */
  csrrs x0, URND_CTRL, x10 /* STOP */
  bn.wsrr w15, URND_STATE

  /* One bn.mulvm advances the stopped PRNG four times. After each qword, the internal registers
   * are cleared.
   */
  bn.mulvm.8S w4, w31, w31
  bn.wsrr w5, URND_STATE

  /* Restore the saved state and advance it with four URND reads. */
  csrrs x0, URND_CTRL, x12 /* RESTORE */
  bn.mov w10, w15
  loopi 6, 2
    bn.wsrw URND_STATE, w10
    bn.rshi w10, w31, w10 >> 32
  bn.wsrr w0, URND
  bn.wsrr w0, URND
  bn.wsrr w0, URND
  bn.wsrr w0, URND
  bn.wsrr w6, URND_STATE

  /* Both states must match. */
  bn.xor w7, w5, w6
  csrrs x5, FG0, x0
  andi  x6, x5, 0x8
  bne   x6, x0, _done
  unimp

_done:
  ecall
